# Apalis imx6 
SUPERVISOR_REPOSITORY_apalis-imx6 = "resin/armv7hf-supervisor"
# Colibri imx6 
SUPERVISOR_REPOSITORY_colibri-imx6 = "resin/armv7hf-supervisor"
